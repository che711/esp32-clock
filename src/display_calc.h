#pragma once
#include <stdint.h>
#include <math.h>

// ============================================================
//  display_calc.h — уровень яркости → регистры тока SSD1322.
//
//  Без Arduino: собирается нативно и покрыто тестами.
//  Отправка в панель — в display.cpp.
//
//  Почему одного contrast мало. Ток сегмента у SSD1322 задаётся
//  двумя регистрами сразу: Contrast Current (0xC1, 0..255) и
//  Master Current (0xC7, 0..15) — ток пропорционален произведению
//  (contrast+1)·(master+1), то есть шкала на деле не 256 шагов,
//  а 4096. Инициализация u8g2 ставит master на максимум и больше
//  его не трогает, поэтому вся регулировка через setContrast()
//  живёт в верхних 6 % диапазона: даже contrast 1 из 255 — это
//  1/256 полного тока, а панель на нём светит вполне заметно.
//
//  Второе — глаз. Ток линеен, восприятие нет: половина тока
//  выглядит примерно как три четверти яркости. Линейная шкала
//  поэтому почти вся «съедается» вверху — от 40 % до 100 % разницы
//  почти не видно, — а внизу обрывается в темноту одним шагом.
//  Отсюда степень 2.2, та же гамма, что у sRGB: равные шаги
//  ползунка дают примерно равные шаги на глаз.
// ============================================================

struct PanelDrive {
    uint8_t master;    // 0xC7, 0..15  — грубо, шаг сразу в разы
    uint8_t contrast;  // 0xC1, 0..255 — тонко
};

// Полный ход шкалы: (master+1) * (contrast+1).
static const uint32_t PANEL_DRIVE_MAX = 16UL * 256UL;
static const float    PANEL_GAMMA     = 2.2f;

// level — шкала интерфейса, 0..255 (CONTRAST_MAX из clock_utils.h).
// Ноль сюда не приходит: нулевая яркость гасит панель целиком, и это
// делает display.cpp через power save — регистрами тока панель до конца
// не погасить.
inline PanelDrive panelDriveForLevel(uint8_t level) {
    float    rel   = (float)level / 255.0f;
    uint32_t units = (uint32_t)(PANEL_DRIVE_MAX * powf(rel, PANEL_GAMMA) + 0.5f);
    if (units < 1)               units = 1;
    if (units > PANEL_DRIVE_MAX) units = PANEL_DRIVE_MAX;

    // Master поднимаем, только когда contrast уже не вмещает остаток:
    // тонкая регулировка должна доставаться более длинному регистру,
    // иначе шаги шкалы получались бы вчетверо крупнее нужного.
    uint32_t m = (units + 255) / 256;   // 1..16
    uint32_t c = units / m;             // 1..256
    if (c < 1)   c = 1;
    if (c > 256) c = 256;

    return PanelDrive{ (uint8_t)(m - 1), (uint8_t)(c - 1) };
}

// Доля полного тока, 0..1 — для тестов и отладки: по регистрам обратно.
inline float panelDriveFraction(PanelDrive d) {
    return (float)((uint32_t)(d.master + 1) * (uint32_t)(d.contrast + 1))
           / (float)PANEL_DRIVE_MAX;
}

// ── Мигание знака разряда ────────────────────────────────
//
// Ниже BATTERY_BLINK_PCT перечёркнутая батарея мигает секунда на секунду.
// sec — секунда кадра, не millis(). Полный кадр перерисовывается ровно на
// смене секунды (main.cpp), поэтому парность той же секунды даёт честную
// секунду на секунду. От millis() это были бы два независимых таймера —
// период кадра и период мигания, — и там, где они расходятся, знак застревал
// бы в одной фазе на два кадра подряд. Заодно внеочередная перерисовка
// (forceRedraw из дашборда) внутри той же секунды повторяет ту же фазу,
// а не даёт лишний моргок.
//
// Выше порога — всегда true: гасить нечего, и вызывающему не нужно знать,
// мигает знак в этом кадре или просто горит.
inline bool battWarnVisible(uint8_t pct, uint32_t sec, uint8_t blinkPct) {
    if (pct > blinkPct) return true;
    return (sec & 1u) == 0;
}
